AUTOSAR XML (schema 4-2-2)
package /System
  system System: category=SYSTEM_EXTRACT
    system mapping SystemMapping
      data-mappings:
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.HVCntctrStat, system-signal=HVCntctrStat
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.HVBatFltSevrtyStat, system-signal=HVBatFltSevrtyStat
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.BMSlightReq, system-signal=BMSlightReq
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.HVCntctrStatARC, system-signal=HVCntctrStatARC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.ChrgrStatPTHVCntctrReq, system-signal=ChrgrStatPTHVCntctrReq
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.HVBatPrcdCrntV, system-signal=HVBatPrcdCrntV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_1D8h.HVBatPrcdCrnt, system-signal=HVBatPrcdCrnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_329h.MesCellTempNumIndex, system-signal=MesCellTempNumIndex
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_329h.CellTempMes{1..7}, system-signal=CellTempMes{1..7}
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.MesCellVoltNumIndex, system-signal=MesCellVoltNumIndex
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes1CellVolt, system-signal=Mes1CellVolt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes1CellBalState, system-signal=Mes1CellBalState
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes2CellVolt, system-signal=Mes2CellVolt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes2CellBalState, system-signal=Mes2CellBalState
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes3CellVolt, system-signal=Mes3CellVolt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_32Ah.Mes3CellBalState, system-signal=Mes3CellBalState
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3D7h.HVBatPackPrcdVltg, system-signal=HVBatPackPrcdVltg
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3D7h.HVBatPackPrcdVltgV, system-signal=HVBatPackPrcdVltgV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.HVBCP_LngTrmChrgPwr, system-signal=HVBCP_LngTrmChrgPwr
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.HVBCP_CrnkChrgPwrV, system-signal=HVBCP_CrnkChrgPwrV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.HVBCP_ShrtTrmChrgPwr, system-signal=HVBCP_ShrtTrmChrgPwr
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.ChrgPeakTimeFactor, system-signal=ChrgPeakTimeFactor
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.BMSChecksum_3DAh, system-signal=BMSChecksum_3DAh
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DAh.HVBatSOCHiRes, system-signal=HVBatSOCHiRes
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DBh.HVBDP_LngTrmDischrgPwr, system-signal=HVBDP_LngTrmDischrgPwr
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DBh.HVBDP_CrnkDischrgPwrV, system-signal=HVBDP_CrnkDischrgPwrV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DBh.HVBDP_ShrtTrmDischrgPwr, system-signal=HVBDP_ShrtTrmDischrgPwr
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DBh.DischrgPeakTimeFactor, system-signal=DischrgPeakTimeFactor
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_3DBh.BMSChecksum_3DBh, system-signal=BMSChecksum_3DBh
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.HVIsoWarning, system-signal=HVIsoWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.HVILWarning, system-signal=HVILWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.SOCLowWarning, system-signal=SOCLowWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.TempDiffWarning, system-signal=TempDiffWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.TempHighWarning, system-signal=TempHighWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.PackOvWarning, system-signal=PackOvWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.PackUvWarning, system-signal=PackUvWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.CellOvWarning, system-signal=CellOvWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.CellUvWarning, system-signal=CellUvWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.SOCHighWarning, system-signal=SOCHighWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.SOCFastChgWarning, system-signal=SOCFastChgWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.PwrBatPackMismatchWarning, system-signal=PwrBatPackMismatchWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.BMSCelConsistencyWarning, system-signal=BMSCelConsistencyWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.BMSVolHighWarning, system-signal=BMSVolHighWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.EnergyConsumptionPer, system-signal=EnergyConsumptionPer
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.RestEnergy, system-signal=RestEnergy
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_503h.BMSCellQuantity, system-signal=BMSCellQuantity
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_503h.BMSTempProbeQuantity, system-signal=BMSTempProbeQuantity
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_503h.HVIsoValue, system-signal=HVIsoValue
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_509h.RechgEnergyStorSysNumb, system-signal=RechgEnergyStorSysNumb
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_509h.CurRechgEnergyStorSysIndex, system-signal=CurRechgEnergyStorSysIndex
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_509h.RechgEnergyStorSysCodeLength, system-signal=RechgEnergyStorSysCodeLength
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_509h.RechgEnergyStorSysCodeIndex, system-signal=RechgEnergyStorSysCodeIndex
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_509h.RechgEnergyStorSysCode{1..6}, system-signal=RechgEnergyStorSysCode{1..6}
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.MaxClVlt, system-signal=MaxClVlt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.MaxCellVoltNumb, system-signal=MaxCellVoltNumb
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.MinClVlt, system-signal=MinClVlt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.MinCellVoltNumb, system-signal=MinCellVoltNumb
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.HVBatPackAccVltgV, system-signal=HVBatPackAccVltgV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_594h.HVBatPackAccVltg, system-signal=HVBatPackPrcdVltg
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_596h.MaxBatTmp, system-signal=MaxBatTmp
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_596h.MaxCellTempNumb, system-signal=MaxCellTempNumb
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_596h.MinBatTmp, system-signal=MinBatTmp
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_596h.MinCellTempNumb, system-signal=MinCellTempNumb
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.BatLf, system-signal=BatLf
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.ChrgPlugStatus, system-signal=ChrgPlugStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.PreChrgUnitRdy, system-signal=PreChrgUnitRdy
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.BMSChrgStatus, system-signal=BMSChrgStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.HVSystemStatus, system-signal=HVSystemStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_598h.TotalBatteryCap, system-signal=TotalBatteryCap
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.ACChrgVoltRq, system-signal=ACChrgVoltRq
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.ACChrgCurrRq, system-signal=ACChrgCurrRq
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.ACChrgMode, system-signal=ACChrgMode
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.ACChrgFault, system-signal=ACChrgFault
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.CCVaule, system-signal=CCVaule
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.CPVaule, system-signal=CPVaule
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_605h.FullChargeRemainingTime, system-signal=FullChargeRemainingTime
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_605h.RequestChargeCurrent, system-signal=RequestChargeCurrent
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_605h.ChargingVoltage, system-signal=ChargingVoltage
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.StopChargingReson, system-signal=StopChargingReson
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CRM00, system-signal=BEM_CRM00
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CRMAA, system-signal=BEM_CRMAA
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CML, system-signal=BEM_CML
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CRO, system-signal=BEM_CRO
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CCS, system-signal=BEM_CCS
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CST, system-signal=BEM_CST
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_CSD, system-signal=BEM_CSD
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BEM_Other, system-signal=BEM_Other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BRM, system-signal=CEM_BRM
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BCP, system-signal=CEM_BCP
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BRO, system-signal=CEM_BRO
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BCS, system-signal=CEM_BCS
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BCL, system-signal=CEM_BCL
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BST, system-signal=CEM_BST
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_BSD, system-signal=CEM_BSD
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CEM_Other, system-signal=CEM_Other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.BMSStopChargeFaultCode{1..8}, system-signal=BMSStopChargeFaultCode{1..8}
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CHGStopChargeFaultCode{1..7}, system-signal=CHGStopChargeFaultCode{1..7}
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCSeriousLevel, system-signal=BMSDTCSeriousLevel
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCHighByte, system-signal=BMSDTCHighByte
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCLowByte, system-signal=BMSDTCLowByte
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCFailureTypeByte, system-signal=BMSDTCFailureTypeByte
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCStatus, system-signal=BMSDTCStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_795h.BMSDTCType, system-signal=BMSDTCType
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_606h.CHGStopChargeFaultCode8, system-signal=CHGStopChargeFaultCode8
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.DCDC_303h.I_LDC_In, system-signal=I_LDC_In
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysPwrMd, system-signal=SysPwrMd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysOpnlMd, system-signal=SysOpnlMd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysVolMdV, system-signal=SysVolMdV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysVolV, system-signal=SysVolV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysVol, system-signal=SysVol
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_BCM_1F1h.SysVolMd, system-signal=SysVolMd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_ABS_23Ch.VehicleSpeedStatus, system-signal=VehicleSpeedStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_ABS_23Ch.VehicleSpeed, system-signal=VehicleSpeed
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_ABS_23Ch.MessageCounter_23Ch, system-signal=MessageCounter_23Ch
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_ABS_23Ch.CheckSum_23Ch, system-signal=CheckSum_23Ch
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_HCM_55Fh.FrontCompStatFdbck, system-signal=FrontCompStatFdbck
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_HCM_55Fh.FrontCmprElctrCrnt, system-signal=FrontCmprElctrCrnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_HCM_55Fh.FrontPTCStatFdbck, system-signal=FrontPTCStatFdbck
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_HCM_55Fh.FrontPTCElctrCrnt, system-signal=FrontPTCElctrCrnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_IPK_1F2h.SysBPM, system-signal=SysBPM
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_IPK_1F2h.SysBPMEnbd, system-signal=SysBPMEnbd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_IPK_362h.HighPreVehOdo, system-signal=HighPreVehOdo
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_IPK_362h.HighPreVehOdoV, system-signal=HighPreVehOdoV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCChgVolt, system-signal=OBCChgVolt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCChgCurrent, system-signal=OBCChgCurrent
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCMaxChrgVoltage, system-signal=OBCMaxChrgVoltage
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCMaxChrgCurrent, system-signal=OBCMaxChrgCurrent
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCStatus, system-signal=OBCStatus
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCCurrentFltCode, system-signal=OBCCurrentFltCode
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.PEU_0B4h.V_DC, system-signal=V_DC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.PEU_0B4h.V_DCValidity, system-signal=V_DCValidity
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.PEU_18Bh.InvADCCrntV, system-signal=InvADCCrntV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.PEU_18Bh.InvADCCrnt, system-signal=InvADCCrnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_SRS_163h.RollingCounter, system-signal=RollingCounter
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_SRS_163h.SRSCheckSum, system-signal=SRSCheckSum
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_SRS_163h.VehCrshTyp, system-signal=VehCrshTyp
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_1E3h.ChrgrStatPTHVCntctrClsAlwd, system-signal=ChrgrStatPTHVCntctrClsAlwd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_1E3h.ChrgrStatPTHVCntctOpnrAlwd, system-signal=ChrgrStatPTHVCntctOpnrAlwd
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_1E3h.PTHVCntctrReq, system-signal=PTHVCntctrReq
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_1E3h.RollingCounter_1E3h, system-signal=RollingCounter_1E3h
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_1E3h.CheckSum_1E3h, system-signal=CheckSum_1E3h
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_353h.VehSpdAvgDrvnV, system-signal=VehSpdAvgDrvnV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.VCU_353h.VehSpdAvgDrvn, system-signal=VehSpdAvgDrvn
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.ThermalAlarm, system-signal=ThermalAlarm
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_501h.ThermalAlarmV, system-signal=ThermalAlarmV
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_503h.RealSOC, system-signal=RealSOC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BMS_603h.S2_Status, system-signal=S2_Status
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.DCDC_303h.CDU_HVILWarning, system-signal=CDU_HVILWarning
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.OBC_604h.OBCHistoryFltCode, system-signal=OBCHistoryFltCode
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BHM_BCU.BHM_SPN2601_Ubat_Max_Permit, system-signal=BHM_SPN2601_Ubat_Max_Permit
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CHM_CHG.CHM_SPN2600_Comm_Ver, system-signal=CHM_SPN2600_Comm_Ver
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2816_Ucell_Max_Permit, system-signal=BCP_SPN2816_Ucell_Max_Permit
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2817_I_Max_Permit, system-signal=BCP_SPN2817_I_Max_Permit
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2818_kWh_Nom, system-signal=BCP_SPN2818_kWh_Nom
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2819_U_Max_Permit, system-signal=BCP_SPN2819_U_Max_Permit
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2820_T_Max_Permit, system-signal=BCP_SPN2820_T_Max_Permit
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2821_SOC, system-signal=BCP_SPN2821_SOC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCP_BCU.BCP_SPN2822_U, system-signal=BCP_SPN2822_U
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3075_U_Mea, system-signal=BCS_SPN3075_U_Mea
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3076_I_Mea, system-signal=BCS_SPN3076_I_Mea
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3077_Ucell_Max, system-signal=BCS_SPN3077_Ucell_Max
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3077_Ucell_Max_Grp, system-signal=BCS_SPN3077_Ucell_Max_Grp
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3078_SOC, system-signal=BCS_SPN3078_SOC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCS_BCU.BCS_SPN3079_Time_Remain, system-signal=BCS_SPN3079_Time_Remain
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CRO_CHG.CRO_SPN2830_CHG_Ready, system-signal=CRO_SPN2830_CHG_Ready
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRO_BCU.BRO_SPN2829_BCU_Ready, system-signal=BRO_SPN2829_BCU_Ready
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CML_CHG.CML_SPN2827_I_Min_Out, system-signal=CML_SPN2827_I_Min_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CML_CHG.CML_SPN2826_I_Max_Out, system-signal=CML_SPN2826_I_Max_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CML_CHG.CML_SPN2825_U_Min_Out, system-signal=CML_SPN2825_U_Min_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CML_CHG.CML_SPN2824_U_Max_Out, system-signal=CML_SPN2824_U_Max_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_YearThousand, system-signal=CTS_SPN2823_SYNC_YearThousand
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_YearTen, system-signal=CTS_SPN2823_SYNC_YearTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_YearHundred, system-signal=CTS_SPN2823_SYNC_YearHundred
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Year, system-signal=CTS_SPN2823_SYNC_Year
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_SecondTen, system-signal=CTS_SPN2823_SYNC_SecondTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Second, system-signal=CTS_SPN2823_SYNC_Second
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_MonthTen, system-signal=CTS_SPN2823_SYNC_MonthTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Month, system-signal=CTS_SPN2823_SYNC_Month
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_MinuteTen, system-signal=CTS_SPN2823_SYNC_MinuteTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Minute, system-signal=CTS_SPN2823_SYNC_Minute
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_HourTen, system-signal=CTS_SPN2823_SYNC_HourTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Hour, system-signal=CTS_SPN2823_SYNC_Hour
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_DayTen, system-signal=CTS_SPN2823_SYNC_DayTen
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CTS_CHG.CTS_SPN2823_SYNC_Day, system-signal=CTS_SPN2823_SYNC_Day
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2576_BMSVer_Year, system-signal=BRM_SPN2576_BMSVer_Year
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2576_BMSVer_Version, system-signal=BRM_SPN2576_BMSVer_Version
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2576_BMSVer_Reserver, system-signal=BRM_SPN2576_BMSVer_Reserver
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2576_BMSVer_Month, system-signal=BRM_SPN2576_BMSVer_Month
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2576_BMSVer_Day, system-signal=BRM_SPN2576_BMSVer_Day
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2575_VIN{1..17}, system-signal=BRM_SPN2575_VIN{1..17}
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2574_BMSSW_Reserved, system-signal=BRM_SPN2574_BMSSW_Reserved
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2572_PackChgCnt, system-signal=BRM_SPN2572_PackChgCnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2573_PackRight, system-signal=BRM_SPN2573_PackRight
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2571_PackDay, system-signal=BRM_SPN2571_PackDay
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2571_PackMonth, system-signal=BRM_SPN2571_PackMonth
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2571_PackYear, system-signal=BRM_SPN2571_PackYear
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2570_PackSN, system-signal=BRM_SPN2570_PackSN
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2569_BatFactory, system-signal=BRM_SPN2569_BatFactory
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2565_Ver, system-signal=BRM_SPN2565_Ver
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2566_Bat_Type, system-signal=BRM_SPN2566_Bat_Type
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2567_Cap_Nom, system-signal=BRM_SPN2567_Cap_Nom
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BRM_BCU.BRM_SPN2568_U_Nom, system-signal=BRM_SPN2568_U_Nom
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CRM_CHG.CRM_SPN2562_CHG_Loc, system-signal=CRM_SPN2562_CHG_Loc
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CRM_CHG.CRM_SPN2561_CHG_Index, system-signal=CRM_SPN2561_CHG_Index
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CRM_CHG.CRM_SPN2560_Ack, system-signal=CRM_SPN2560_Ack
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_other, system-signal=CEM_other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3927_Timeout_BSD, system-signal=CEM_SPN3927_Timeout_BSD
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3926_Timeout_BST, system-signal=CEM_SPN3926_Timeout_BST
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3925_Timeout_BCL, system-signal=CEM_SPN3925_Timeout_BCL
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3924_Timeout_BCS, system-signal=CEM_SPN3924_Timeout_BCS
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3923_Timeout_BRO, system-signal=CEM_SPN3923_Timeout_BRO
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3922_Timeout_BCP, system-signal=CEM_SPN3922_Timeout_BCP
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CEM_CHG.CEM_SPN3921_Timeout_BRM, system-signal=CEM_SPN3921_Timeout_BRM
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_other, system-signal=BEM_other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3907_Timeout_CSD, system-signal=BEM_SPN3907_Timeout_CSD
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3906_Timeout_CST, system-signal=BEM_SPN3906_Timeout_CST
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3905_Timeout_CCS, system-signal=BEM_SPN3905_Timeout_CCS
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3904_Timeout_CRO, system-signal=BEM_SPN3904_Timeout_CRO
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3903_Timeout_CTS_CML, system-signal=BEM_SPN3903_Timeout_CTS_CML
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3902_Timeout_SPN2560_0xAA, system-signal=BEM_SPN3902_Timeout_SPN2560_0xAA
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BEM_BCU.BEM_SPN3901_Timeout_SPN2560_0x00, system-signal=BEM_SPN3901_Timeout_SPN2560_0x00
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CSD_CHG.CSD_SPN3613_CHG_Index, system-signal=CSD_SPN3613_CHG_Index
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CSD_CHG.CSD_SPN3612_E_Out, system-signal=CSD_SPN3612_E_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CSD_CHG.CSD_SPN3611_Time_Charged, system-signal=CSD_SPN3611_Time_Charged
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSD_BCU.BSD_SPN3605_T_Max, system-signal=BSD_SPN3605_T_Max
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSD_BCU.BSD_SPN3604_T_Min, system-signal=BSD_SPN3604_T_Min
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSD_BCU.BSD_SPN3603_Ucell_Max, system-signal=BSD_SPN3603_Ucell_Max
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSD_BCU.BSD_SPN3602_Ucell_Min, system-signal=BSD_SPN3602_Ucell_Min
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSD_BCU.BSD_SPN3601_SOC_Final, system-signal=BSD_SPN3601_SOC_Final
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3521_Stop_Reason_BMSStop, system-signal=CST_SPN3521_Stop_Reason_BMSStop
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3523_Stop_Fault_U, system-signal=CST_SPN3523_Stop_Fault_U
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3523_Stop_Fault_Mismatch, system-signal=CST_SPN3523_Stop_Fault_Mismatch
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_T_Inter, system-signal=CST_SPN3522_Stop_Fault_T_Inter
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_T_CHG, system-signal=CST_SPN3522_Stop_Fault_T_CHG
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_Other, system-signal=CST_SPN3522_Stop_Fault_Other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_EmerStop, system-signal=CST_SPN3522_Stop_Fault_EmerStop
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_Deliver, system-signal=CST_SPN3522_Stop_Fault_Deliver
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3522_Stop_Fault_CHGCnnt, system-signal=CST_SPN3522_Stop_Fault_CHGCnnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3521_Stop_Reason_Manual, system-signal=CST_SPN3521_Stop_Reason_Manual
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3521_Stop_Reason_Fault, system-signal=CST_SPN3521_Stop_Reason_Fault
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CST_CHG.CST_SPN3521_Stop_Reason_Auto, system-signal=CST_SPN3521_Stop_Reason_Auto
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_HVRelay, system-signal=BST_SPN3512_Stop_Fault_HVRelay
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_CC2, system-signal=BST_SPN3512_Stop_Fault_CC2
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3511_Stop_Reason_CHGStop, system-signal=BST_SPN3511_Stop_Reason_CHGStop
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3513_Stop_Fault_U, system-signal=BST_SPN3513_Stop_Fault_U
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3513_Stop_Fault_I, system-signal=BST_SPN3513_Stop_Fault_I
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_T, system-signal=BST_SPN3512_Stop_Fault_T
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_Other, system-signal=BST_SPN3512_Stop_Fault_Other
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_Iso, system-signal=BST_SPN3512_Stop_Fault_Iso
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_OutCnnt, system-signal=BST_SPN3512_Stop_Fault_OutCnnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_BCUcompo, system-signal=BST_SPN3512_Stop_Fault_BCUcompo
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3512_Stop_Fault_ChgCnnt, system-signal=BST_SPN3512_Stop_Fault_ChgCnnt
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3511_Stop_Reason_Ucell, system-signal=BST_SPN3511_Stop_Reason_Ucell
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3511_Stop_Reason_U, system-signal=BST_SPN3511_Stop_Reason_U
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BST_BCU.BST_SPN3511_Stop_Reason_SOC, system-signal=BST_SPN3511_Stop_Reason_SOC
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3096_Chg_Enable, system-signal=BSM_SPN3096_Chg_Enable
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3095_OutConnector_State, system-signal=BSM_SPN3095_OutConnector_State
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3094_Iso_State, system-signal=BSM_SPN3094_Iso_State
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3093_T_Warn, system-signal=BSM_SPN3093_T_Warn
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3092_I_Warn, system-signal=BSM_SPN3092_I_Warn
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3091_SOC_Warn, system-signal=BSM_SPN3091_SOC_Warn
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3090_Ucell_Warn, system-signal=BSM_SPN3090_Ucell_Warn
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3089_T_Min_Index, system-signal=BSM_SPN3089_T_Min_Index
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3088_T_Min, system-signal=BSM_SPN3088_T_Min
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3087_T_Max_Index, system-signal=BSM_SPN3087_T_Max_Index
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3086_T_Max, system-signal=BSM_SPN3086_T_Max
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BSM_BCU.BSM_SPN3085_Ucell_Max_Index, system-signal=BSM_SPN3085_Ucell_Max_Index
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CCS_CHG.CCS_SPN3081_U_Out, system-signal=CCS_SPN3081_U_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CCS_CHG.CCS_SPN3082_I_Out, system-signal=CCS_SPN3082_I_Out
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CCS_CHG.CCS_SPN3083_Time_Charged, system-signal=CCS_SPN3083_Time_Charged
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.CCS_CHG.CCS_SPN3929_Chg_enable, system-signal=CCS_SPN3929_Chg_enable
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCL_BCU.BCL_SPN3074_ChgMode, system-signal=BCL_SPN3074_ChgMode
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCL_BCU.BCL_SPN3073_I_Req, system-signal=BCL_SPN3073_I_Req
        data-element=CPT_Asw_Swc.RootSwCompositionPrototype.BCL_BCU.BCL_SPN3072_U_Req, system-signal=BCL_SPN3072_U_Req
      sw-mappings:
        swc to ecu mapping SwcToEcuMapping: ecu-instance=BMS
          component:
            RootSwCompositionPrototype.CPT_BswM
            RootSwCompositionPrototype.CPT_ComM
            RootSwCompositionPrototype.CPT_EcuM
            RootSwCompositionPrototype.CPT_Det
            RootSwCompositionPrototype.CPT_Xcp_SWC
            RootSwCompositionPrototype.CPT_WdgM
            RootSwCompositionPrototype.CPT_WdgM_SWC
            RootSwCompositionPrototype.CPT_NvM
            RootSwCompositionPrototype.CPT_IoHwAb
            RootSwCompositionPrototype.CPT_Sbc_Cdd
            RootSwCompositionPrototype.CPT_Cmu_Cdd
            RootSwCompositionPrototype.CPT_Asw_Swc
    root-software-compositions:
      root sw composition prototype RootSwCompositionPrototype: software-composition=TopLevelComposition
package /EcucValueCollection
  ecuc value collection EcucValueCollection: ecu-extract=EXTR_BMSL, ecuc-values=[Os, Rte, ComM, EcuM, Com, CanSm, BswM, CanIf, PduR, Det, Xcp, WdgM, WdgIf, NvM, MemIf, Ea, J1939Tp]
package /DBC_SysDesc_Can_Network/Pkg_Cluster
  can cluster Can_Network_0: protocol-name=CAN
    can physical channel Can_Network_0_Channel: comm-connectors=Conn_Can_Network_CANNODE_0_BMS
      frame PEU_0B4h: id 0xB4, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu PEU_0B4h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu PEU_0B4h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10230, min=0, offset=0}, i-signal-in-i-pdu=V_DC}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=V_DCValidity}
          signal V_DC: start 54, 15 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # EPT DC Link voltage直流母线电压 toIPK Tbox法规强制 "
          signal V_DCValidity: start 55, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # EPT DC Link voltage Validity toIPK "
      frame VCU_1E3h: id 0x1E3, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_1E3h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_1E3h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=PTHVCntctrReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ChrgrStatPTHVCntctrClsAlwd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ChrgrStatPTHVCntctOpnrAlwd}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=RollingCounter_1E3h}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=CheckSum_1E3h}
          signal PTHVCntctrReq: start 4, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Powertrain High Voltage Contactor Request "
          signal ChrgrStatPTHVCntctrClsAlwd: start 0, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Charger Status Powertrain High Voltage Contactor Close Allowed "
          signal ChrgrStatPTHVCntctOpnrAlwd: start 1, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Charger Status Powertrain High Voltage Contactor Open Allowed "
          signal RollingCounter_1E3h: start 55, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # "
          signal CheckSum_1E3h: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # CheckSum=Byet(0) XOR Byte(1)XOR Byte(2) XOR Byte(3) XOR Byte(4)XOR Byte(5) XOR Byte(6) "
      frame PEU_18Bh: id 0x18B, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu PEU_18Bh: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu PEU_18Bh: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=InvADCCrntV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=32767, min=0}, i-signal-in-i-pdu=InvADCCrnt}
          signal InvADCCrntV: start 55, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Inverter A DC Current Validity toIPK "
          signal InvADCCrnt: start 54, 15 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Inverter A DC Current toIPK 逆变器DC电流 "
      frame VCU_ABS_23Ch: id 0x23C, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_ABS_23Ch: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_ABS_23Ch: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VehicleSpeedStatus}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=32767, min=0, offset=0}, i-signal-in-i-pdu=VehicleSpeed}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=MessageCounter_23Ch}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=CheckSum_23Ch}
          signal VehicleSpeedStatus: start 7, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # "
          signal VehicleSpeed: start 6, 15 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # "
          signal MessageCounter_23Ch: start 55, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # "
          signal CheckSum_23Ch: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Checksum=byte(0) XOR byte(1) XOR byte(2) XOR byte(3) XOR byte(4) XOR byte(5) XOR byte(6) "
      frame DCDC_303h: id 0x303, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu DCDC_303h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu DCDC_303h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4095, min=0, offset=0}, i-signal-in-i-pdu=I_LDC_In}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CDU_HVILWarning}
          signal I_LDC_In: start 27, 12 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # LDC input current "
          signal CDU_HVILWarning: start 7, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # High voltage Inter Lock warning "
      frame VCU_BCM_1F1h: id 0x1F1, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_BCM_1F1h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_BCM_1F1h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=SysPwrMd}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=SysOpnlMd}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=SysVolMdV}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=SysVolV}
            {data-filter={data-filter-type=ALWAYS, max=255, min=-30, offset=3}, i-signal-in-i-pdu=SysVol}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=SysVolMd}
          signal SysPwrMd: start 1, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Power Mode "
          signal SysOpnlMd: start 6, 3 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Operational Mode "
          signal SysVolMdV: start 7, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Voltage Mode valid "
          signal SysVolV: start 32, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # "
          signal SysVol: start 47, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Battery Voltage "
          signal SysVolMd: start 58, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Voltage Mode "
      frame Tester_748h: id 0x748, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu Tester_748h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu Tester_748h: length=8, transmission-mode-condition{data-filter={data-filter-type=NEW-IS-WITHIN, max=255, min=0, offset=0}, i-signal-in-i-pdu=TesterDiagRequestData_BMS}
          signal TesterDiagRequestData_BMS: start 7, 64 bit, big-endian, init-value=0, base-type=uint64, update-indication-bit-position=-1, to BMS  # "
      frame VCU_IPK_1F2h: id 0x1F2, to BMS, frame-length=2, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_IPK_1F2h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_IPK_1F2h: length=2, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=0, min=0, offset=0}, i-signal-in-i-pdu=SysBPM}
            {data-filter={data-filter-type=ALWAYS, max=0, min=0, offset=0}, i-signal-in-i-pdu=SysBPMEnbd}
          signal SysBPM: start 5, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Backup Power Mode "
          signal SysBPMEnbd: start 6, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # System Backup Power Mode Enabled "
      frame VCU_SRS_163h: id 0x163, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_SRS_163h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_SRS_163h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=VehCrshTyp}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=RollingCounter}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=SRSCheckSum}
          signal VehCrshTyp: start 4, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Vehicle Crash Type "
          signal RollingCounter: start 55, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # "
          signal SRSCheckSum: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Checksum=byte(0) XOR byte(1) XOR byte(2)XOR byte(3) XOR byte(4)XOR byte(5)XOR byte(6) "
      frame VCU_353h: id 0x353, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_353h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_353h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=0, min=0, offset=0}, i-signal-in-i-pdu=VehSpdAvgDrvnV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=32767, min=0, offset=0}, i-signal-in-i-pdu=VehSpdAvgDrvn}
          signal VehSpdAvgDrvnV: start 7, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Vehicle Speed Average Driven Validity "
          signal VehSpdAvgDrvn: start 6, 15 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Vehicle Speed Average Driven "
      frame Tester_7DFh: id 0x7DF, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu Tester_7DFh: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu Tester_7DFh: length=8, transmission-mode-condition{data-filter={data-filter-type=NEW-IS-WITHIN, max=255, min=0, offset=0}, i-signal-in-i-pdu=TesterDiagRequestData_Fun}
          signal TesterDiagRequestData_Fun: start 7, 64 bit, big-endian, init-value=0, base-type=uint64, update-indication-bit-position=-1, to BMS  # "
      frame VCU_HCM_55Fh: id 0x55F, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_HCM_55Fh: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_HCM_55Fh: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=FrontCompStatFdbck}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=FrontCmprElctrCrnt}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=FrontPTCStatFdbck}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=FrontPTCElctrCrnt}
          signal FrontCompStatFdbck: start 6, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Front Compressor Status Feedback 正常工作发0，不工作发2；1和3不触发 "
          signal FrontCmprElctrCrnt: start 39, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Front Compressor Electrical Current "
          signal FrontPTCStatFdbck: start 41, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Front PTC Status Feedback EV31空调只能反馈继电器状态 正常工作发0，不工作发2；1和3不触发 "
          signal FrontPTCElctrCrnt: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # Front PTC Electrical Current EV31台架上加350V的电压，测出1、2、3….档对应的电流值。 "
      frame OBC_604h: id 0x604, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu OBC_604h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu OBC_604h: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=OBCChgVolt}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=OBCChgCurrent}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=OBCMaxChrgVoltage}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=OBCMaxChrgCurrent}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=OBCStatus}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=0}, i-signal-in-i-pdu=OBCCurrentFltCode}
            {data-filter={data-filter-type=ALWAYS, max=31, min=0, offset=0}, i-signal-in-i-pdu=OBCHistoryFltCode}
          signal OBCChgVolt: start 7, 14 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Charger voltage "
          signal OBCChgCurrent: start 9, 10 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Charger current "
          signal OBCMaxChrgVoltage: start 31, 14 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Maximum charger voltage "
          signal OBCMaxChrgCurrent: start 33, 10 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # Maximum charger current "
          signal OBCStatus: start 50, 3 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # OBC Status "
          signal OBCCurrentFltCode: start 55, 5 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # OBC Current fault code Send the most serious fault code "
          signal OBCHistoryFltCode: start 61, 5 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # OBC History fault code Send the most serious fault code "
      frame VCU_IPK_362h: id 0x362, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu VCU_IPK_362h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu VCU_IPK_362h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=1.0}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=1.0}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=9999999, min=0, offset=0}, i-signal-in-i-pdu=HighPreVehOdo}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HighPreVehOdoV}
          signal HighPreVehOdo: start 7, 24 bit, big-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1, to BMS  # High Precision Vehicle Odometer Tbox法规强制 "
          signal HighPreVehOdoV: start 31, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # High Precision Vehicle Odometer Validity "
      frame XCP_CMD: id 0x6C0, to BMS, frame-length=8, can-addressing-mode=STANDARD, can-frame-rx-behavior=ANY
        carries pdu XCP_CMD: start-position=7, update-indication-bit-position=-1
        xcp pdu XCP_CMD: length=8
      frame BMS_329h: id 0x329, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_329h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_329h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=100, min=1, offset=0}, i-signal-in-i-pdu=MesCellTempNumIndex}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=CellTempMes{1..7}}
          signal MesCellTempNumIndex: start 7, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # MesCellTempNumIndex详细温度发送序号n "
          signal CellTempMes1: start 15, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+1)个温度 "
          signal CellTempMes2: start 23, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+2)个温度 "
          signal CellTempMes3: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+3)个温度 "
          signal CellTempMes4: start 39, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+4个温度 "
          signal CellTempMes5: start 47, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+5)个温度 "
          signal CellTempMes6: start 55, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+6)个温度 "
          signal CellTempMes7: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 第(7*(n-1)+7)个温度 "
      frame BMS_503h: id 0x503, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_503h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_503h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=250, min=1, offset=0}, i-signal-in-i-pdu=BMSCellQuantity}
            {data-filter={data-filter-type=ALWAYS, max=100, min=1, offset=0}, i-signal-in-i-pdu=BMSTempProbeQuantity}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=RealSOC}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=HVIsoValue}
          signal BMSCellQuantity: start 7, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # BMSCellQuantity 单体电池数量 Tbox法规强制 "
          signal BMSTempProbeQuantity: start 31, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # BMSTempProbeQuantity 温度探针数量 Tbox法规强制 "
          signal RealSOC: start 15, 16 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # "
          signal HVIsoValue: start 36, 13 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High voltage Isolation value send invaild vaule when BMS don't have valid vaule tbox法规强制 "
      frame BMS_501h: id 0x501, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_501h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_501h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=HVIsoWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVILWarning}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=SOCLowWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=TempDiffWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=TempHighWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=PackOvWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=PackUvWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CellOvWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CellUvWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=SOCHighWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=SOCFastChgWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=PwrBatPackMismatchWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BMSCelConsistencyWarning}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BMSVolHighWarning}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65535, min=0, offset=0}, i-signal-in-i-pdu=EnergyConsumptionPer}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65534, min=0, offset=0}, i-signal-in-i-pdu=RestEnergy}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ThermalAlarm}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ThermalAlarmV}
          signal HVIsoWarning: start 1, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High voltage Isolation warning to IPK Tbox法规强制 "
          signal HVILWarning: start 2, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High voltage Inter Lock warning Tbox法规强制 "
          signal SOCLowWarning: start 4, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # SOC Low Warning Tbox法规强制 "
          signal TempDiffWarning: start 5, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Temperature Difference Warning BMS温度差异报警 Tbox法规强制 "
          signal TempHighWarning: start 6, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Temperature High Warning 电池温度报警 Tbox法规强制 "
          signal PackOvWarning: start 7, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Pack Over Voltage warning BMS过压报警 Tbox法规强制 "
          signal PackUvWarning: start 8, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Pack Under Voltage Warning BMS欠压报警 Tbox法规强制 "
          signal CellOvWarning: start 9, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Cell Overvoltage warning 单体电池过压报警Tbox法规强制 "
          signal CellUvWarning: start 10, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Cell UnderVoltage Warning 单体电池欠压报警 Tbox法规强制 "
          signal SOCHighWarning: start 11, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # SOC High Warning SOC过高报警Tbox法规强制 "
          signal SOCFastChgWarning: start 12, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # SOCFastChangeWarning SOC跳变报警 Tbox法规强制 "
          signal PwrBatPackMismatchWarning: start 13, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Power battery pack mismatch Warning 可充电储能系统不匹配报警Tbox法规强制 "
          signal BMSCelConsistencyWarning: start 14, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BMSCell consistency Warning 电池单体一致性差报警 Tbox法规强制 "
          signal BMSVolHighWarning: start 15, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BMSVoltageHighwarning 车载储能装置类型过充Tbox法规强制 "
          signal EnergyConsumptionPer: start 23, 16 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 每100ms的电量消耗（即平均电耗） "
          signal RestEnergy: start 39, 16 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Rest Energy（即剩余电量） "
          signal ThermalAlarm: start 48, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Thermal Alarm 电池热失控报警 "
          signal ThermalAlarmV: start 49, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
      frame BMS_1D8h: id 0x1D8, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_1D8h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_1D8h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=HVCntctrStat}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=HVBatFltSevrtyStat}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=HVCntctrStatARC}
            {data-filter={data-filter-type=ALWAYS, max=2, min=0, offset=0}, i-signal-in-i-pdu=ChrgrStatPTHVCntctrReq}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVBatPrcdCrntV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=12285, min=0}, i-signal-in-i-pdu=HVBatPrcdCrnt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BMSlightReq}
          signal HVCntctrStat: start 2, 3 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Contactor Status to IPK "
          signal HVBatFltSevrtyStat: start 34, 3 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Fault Severity Status to IPK "
          signal HVCntctrStatARC: start 37, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Contactor Status Alive Rolling Count "
          signal ChrgrStatPTHVCntctrReq: start 4, 2 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Charger Status Powertrain High Voltage Contactor Request "
          signal HVBatPrcdCrntV: start 54, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Processed Current Validity to IPK "
          signal HVBatPrcdCrnt: start 53, 14 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Processed Current to IPK Tbox法规强制 "
          signal BMSlightReq: start 35, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BMS Light Request "
      frame BMS_795h: id 0x795, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_795h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_795h: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCSeriousLevel}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCHighByte}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCLowByte}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCFailureTypeByte}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCStatus}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDTCType}
          signal BMSDTCSeriousLevel: start 3, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BMSDTCHighByte: start 15, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 "
          signal BMSDTCLowByte: start 23, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 "
          signal BMSDTCFailureTypeByte: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 "
          signal BMSDTCStatus: start 39, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Tbox法规强制 "
          signal BMSDTCType: start 47, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
      frame XCP_RES_DAQ: id 0x6CF, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu XCP_RES_DAQ: start-position=7, update-indication-bit-position=-1
        xcp pdu XCP_RES_DAQ: length=8
      frame BMS_3D7h: id 0x3D7, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_3D7h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_3D7h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVBatPackPrcdVltgV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0, offset=0}, i-signal-in-i-pdu=HVBatPackPrcdVltg}
          signal HVBatPackPrcdVltgV: start 5, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Pack Processed Voltage Validity to IPK "
          signal HVBatPackPrcdVltg: start 4, 13 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Pack Processed Voltage to IPK "
      frame BMS_606h: id 0x606, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_606h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_606h: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=StopChargingReson}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CRM00}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CRMAA}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CML}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CRO}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CCS}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CST}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_CSD}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BEM_Other}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BRM}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BCP}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BRO}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BCS}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BCL}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BST}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_BSD}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CEM_Other}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=BMSStopChargeFaultCode{1..8}}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=CHGStopChargeFaultCode{1..8}}
          signal StopChargingReson: start 7, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # StopChargingReson 充电结束原因 "
          signal BEM_CRM00: start 3, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CRMAA: start 2, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CML: start 1, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CRO: start 0, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CCS: start 15, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CST: start 14, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_CSD: start 13, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BEM_Other: start 12, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BRM: start 11, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BCP: start 10, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BRO: start 9, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BCS: start 8, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BCL: start 23, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BST: start 22, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_BSD: start 21, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal CEM_Other: start 20, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # "
          signal BMSStopChargeFaultCode1: start 19, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # CC2检测点2电压检测故障 "
          signal BMSStopChargeFaultCode2: start 18, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电机最高电压不匹配故障 "
          signal BMSStopChargeFaultCode3: start 17, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 电池温度过低故障（未带加热功能） "
          signal BMSStopChargeFaultCode4: start 31, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 高压继电器故障 "
          signal BMSStopChargeFaultCode5: start 30, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 单体欠压故障 "
          signal BMSStopChargeFaultCode6: start 29, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 电流过大故障 "
          signal BMSStopChargeFaultCode7: start 28, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电连接器过温故障 "
          signal BMSStopChargeFaultCode8: start 27, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 其他故障 "
          signal CHGStopChargeFaultCode1: start 26, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电机过温故障 "
          signal CHGStopChargeFaultCode2: start 25, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电连接器故障 "
          signal CHGStopChargeFaultCode3: start 24, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电机内部过温故障 "
          signal CHGStopChargeFaultCode4: start 39, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 所需能量不能传送故障（功率模块异常） "
          signal CHGStopChargeFaultCode5: start 38, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电机急停故障 "
          signal CHGStopChargeFaultCode6: start 37, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 电流不匹配故障 "
          signal CHGStopChargeFaultCode7: start 36, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 电压异常故障 "
          signal CHGStopChargeFaultCode8: start 35, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 其他故障 "
      frame BMS_598h: id 0x598, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_598h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_598h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.1}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.1}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BatLf}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=ChrgPlugStatus}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=PreChrgUnitRdy}
            {data-filter={data-filter-type=ALWAYS, max=7, min=0, offset=0}, i-signal-in-i-pdu=BMSChrgStatus}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=HVSystemStatus}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=TotalBatteryCap}
          signal BatLf: start 7, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Battery Life to IPK "
          signal ChrgPlugStatus: start 8, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Charge plug status to HCM "
          signal PreChrgUnitRdy: start 10, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # PreCharge Unit is ready for precharge "
          signal BMSChrgStatus: start 13, 3 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BMS Charge Status 法规强制 "
          signal HVSystemStatus: start 23, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # HV System status "
          signal TotalBatteryCap: start 31, 16 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Total battery capacity to IPK "
      frame BMS_509h: id 0x509, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_509h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_509h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.5}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.5}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=15, min=1, offset=0}, i-signal-in-i-pdu=RechgEnergyStorSysNumb}
            {data-filter={data-filter-type=ALWAYS, max=15, min=1, offset=0}, i-signal-in-i-pdu=CurRechgEnergyStorSysIndex}
            {data-filter={data-filter-type=ALWAYS, max=30, min=1, offset=0}, i-signal-in-i-pdu=RechgEnergyStorSysCodeLength}
            {data-filter={data-filter-type=ALWAYS, max=7, min=1, offset=0}, i-signal-in-i-pdu=RechgEnergyStorSysCodeIndex}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=RechgEnergyStorSysCode{1..6}}
          signal RechgEnergyStorSysNumb: start 3, 4 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system number 可充电储能设备个数 "
          signal CurRechgEnergyStorSysIndex: start 7, 4 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Current Rechargeable electronic energy storage system index 当前可充电储能设备序号 "
          signal RechgEnergyStorSysCodeLength: start 12, 5 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code length 当前可充电储能设备编码长度 "
          signal RechgEnergyStorSysCodeIndex: start 15, 3 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code index 当前可充电储能设备编码序号 "
          signal RechgEnergyStorSysCode1: start 23, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+1) info 当前可充电储能设备编码信息1 "
          signal RechgEnergyStorSysCode2: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+2) info 当前可充电储能设备编码信息2 "
          signal RechgEnergyStorSysCode3: start 39, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+3) info 当前可充电储能设备编码信息3 "
          signal RechgEnergyStorSysCode4: start 47, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+4) info 当前可充电储能设备编码信息4 "
          signal RechgEnergyStorSysCode5: start 55, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+5) info 当前可充电储能设备编码信息5 "
          signal RechgEnergyStorSysCode6: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Rechargeable electronic energy storage system code(（index-1）*6+6) info 当前可充电储能设备编码信息6 "
      frame BMS_605h: id 0x605, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_605h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_605h: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=600, min=0, offset=0}, i-signal-in-i-pdu=FullChargeRemainingTime}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=400, min=0, offset=0}, i-signal-in-i-pdu=RequestChargeCurrent}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=ChargingVoltage}
          signal FullChargeRemainingTime: start 7, 10 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # "
          signal RequestChargeCurrent: start 23, 9 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # "
          signal ChargingVoltage: start 39, 14 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # "
      frame BMS_7C8h: id 0x7C8, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_7C8h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_7C8h: length=8, transmission-mode-condition{data-filter={data-filter-type=NEW-IS-WITHIN, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSDiagResponseData}
          signal BMSDiagResponseData: start 7, 64 bit, big-endian, init-value=0, base-type=uint64, update-indication-bit-position=-1  # "
      frame BMS_596h: id 0x596, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_596h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_596h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MaxBatTmp}
            {data-filter={data-filter-type=ALWAYS, max=100, min=1, offset=0}, i-signal-in-i-pdu=MaxCellTempNumb}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=MinBatTmp}
            {data-filter={data-filter-type=ALWAYS, max=100, min=1, offset=0}, i-signal-in-i-pdu=MinCellTempNumb}
          signal MaxBatTmp: start 7, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Maximum cell temperature Tbox法规强制 "
          signal MaxCellTempNumb: start 15, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Maximum cell temperature number Tbox法规强制 "
          signal MinBatTmp: start 23, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Minimum cell Temperature Tbox法规强制 "
          signal MinCellTempNumb: start 31, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Minimum cell temperature number Tbox法规强制 "
      frame BMS_3DAh: id 0x3DA, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_3DAh: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_3DAh: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2047, min=0, offset=0}, i-signal-in-i-pdu=HVBCP_LngTrmChrgPwr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVBCP_CrnkChrgPwrV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2047, min=0, offset=0}, i-signal-in-i-pdu=HVBCP_ShrtTrmChrgPwr}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=ChrgPeakTimeFactor}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65534, min=0, offset=0}, i-signal-in-i-pdu=HVBatSOCHiRes}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSChecksum_3DAh}
          signal HVBCP_LngTrmChrgPwr: start 7, 11 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Charge Power : Long Term Charge Power "
          signal HVBCP_CrnkChrgPwrV: start 11, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Charge Power : Charge Power Validity "
          signal HVBCP_ShrtTrmChrgPwr: start 10, 11 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Charge Power : Short Term Charge Power "
          signal ChrgPeakTimeFactor: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Charging peak power time factor "
          signal HVBatSOCHiRes: start 39, 16 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery State of Charge High Resolution to IPK 高精度电池SOC状态 Tbox法规强制 "
          signal BMSChecksum_3DAh: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Checksum=byte(0) XOR byte(1)XOR byte(2) XOR byte(3)XOR byte(4)XOR byte(5) XOR byte(6) "
      frame BMS_32Ah: id 0x32A, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_32Ah: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_32Ah: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.02}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.02}
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=100, min=1, offset=0}, i-signal-in-i-pdu=MesCellVoltNumIndex}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=Mes1CellVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=Mes1CellBalState}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=Mes2CellVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=Mes2CellBalState}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=Mes3CellVolt}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=Mes3CellBalState}
          signal MesCellVoltNumIndex: start 7, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # MesCellVoltNumIndex详细单体电压发送序号n "
          signal Mes1CellVolt: start 12, 13 bit, big-endian, init-value=8191, base-type=uint16, update-indication-bit-position=-1  # Mes1CellVolt Tbox法规强制 第（3*（n-1）+1）个单体电压 "
          signal Mes1CellBalState: start 13, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Mes1CellBalState 第（3*（n-1）+1）个单体电压均衡状态 "
          signal Mes2CellVolt: start 28, 13 bit, big-endian, init-value=8191, base-type=uint16, update-indication-bit-position=-1  # Mes2CellVolt Tbox法规强制 第（3*（n-1）+2）个单体电压 "
          signal Mes2CellBalState: start 29, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Mes2CellBalState 第（3*（n-1）+2）个单体电压均衡状态 "
          signal Mes3CellVolt: start 44, 13 bit, big-endian, init-value=8191, base-type=uint16, update-indication-bit-position=-1  # Mes3CellVolt Tbox法规强制 第（3*（n-1）+3）个单体电压 "
          signal Mes3CellBalState: start 45, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Mes3CellBalState 第（3*（n-1）+3）个单体电压均衡状态 "
      frame BMS_3DBh: id 0x3DB, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_3DBh: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_3DBh: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.01}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.01}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2047, min=0, offset=0}, i-signal-in-i-pdu=HVBDP_LngTrmDischrgPwr}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVBDP_CrnkDischrgPwrV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2047, min=0, offset=0}, i-signal-in-i-pdu=HVBDP_ShrtTrmDischrgPwr}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=DischrgPeakTimeFactor}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BMSChecksum_3DBh}
          signal HVBDP_LngTrmDischrgPwr: start 7, 11 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Discharge Power : Long Term Discharge Power 恒定放电功率 "
          signal HVBDP_CrnkDischrgPwrV: start 11, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Discharge Power : Discharge Power Validity "
          signal HVBDP_ShrtTrmDischrgPwr: start 10, 11 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Discharge Power : Short Term Discharge Power 瞬时放电功率 "
          signal DischrgPeakTimeFactor: start 31, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # Discharging peak power time factor "
          signal BMSChecksum_3DBh: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BMSChecksum_3DBh Checksum=byte(0) XOR byte(1) XOR byte(2)XOR byte(3) XOR byte(4)XOR byte(5)XOR byte(6) "
      frame BMS_603h: id 0x603, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_603h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_603h: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=ACChrgVoltRq}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=ACChrgCurrRq}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=ACChrgMode}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=ACChrgFault}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=CCVaule}
            {data-filter={data-filter-type=ALWAYS, max=200, min=0, offset=0}, i-signal-in-i-pdu=CPVaule}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=S2_Status}
          signal ACChrgVoltRq: start 13, 14 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Request charge voltage "
          signal ACChrgCurrRq: start 25, 10 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Request charge current "
          signal ACChrgMode: start 47, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # AC charge mode "
          signal ACChrgFault: start 43, 4 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # AC Chrage fault "
          signal CCVaule: start 55, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # CC Status Value "
          signal CPVaule: start 63, 8 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # CP PWM Duty 占空比 "
          signal S2_Status: start 14, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # S2开关状态 "
      frame BMS_594h: id 0x594, from BMS, frame-length=8, can-addressing-mode=STANDARD
        carries pdu BMS_594h: packing-byte-order=big-endian, start-position=7, update-indication-bit-position=-1
        pdu BMS_594h: length=8, transmission-mode-false-timing=cyclic-timing={time-offset=0.0, time-period=0.2}, transmission-mode-true-timing=cyclic-timing={time-offset=0.0, time-period=0.2}
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MaxClVlt}
            {data-filter={data-filter-type=ALWAYS, max=250, min=1, offset=0}, i-signal-in-i-pdu=MaxCellVoltNumb}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=5000, min=0, offset=0}, i-signal-in-i-pdu=MinClVlt}
            {data-filter={data-filter-type=ALWAYS, max=250, min=1, offset=0}, i-signal-in-i-pdu=MinCellVoltNumb}
            {data-filter={data-filter-type=ALWAYS, max=1, min=0, offset=0}, i-signal-in-i-pdu=HVBatPackAccVltgV}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0, offset=0}, i-signal-in-i-pdu=HVBatPackAccVltg}
          signal MaxClVlt: start 4, 13 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Maximum Cell Voltage Tbox法规强制 "
          signal MaxCellVoltNumb: start 23, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Maximum cell voltage number Tbox法规强制 "
          signal MinClVlt: start 28, 13 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # Minimum Cell Voltage Tbox法规强制 "
          signal MinCellVoltNumb: start 47, 8 bit, big-endian, init-value=1, base-type=uint8, update-indication-bit-position=-1  # Minimum cell voltage number Tbox法规强制 "
          signal HVBatPackAccVltgV: start 53, 1 bit, big-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # High Voltage Battery Pack Accumulate Voltage Validity "
          signal HVBatPackAccVltg: start 52, 13 bit, big-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # High Voltage Battery Pack Accumulate Voltage 单体电压累加总电压 Tbox法规强制 "
package /DBC_SysDesc_Can_Network/Pkg_Ecu
  ecu instance BMS: com-configuration-gw-time-base=0.005, com-configuration-rx-time-base=0.01, com-configuration-tx-time-base=0.01, sleep-mode-supported=false, wake-up-over-bus-supported=false
    can communication controller Can_Network_CANNODE_0: can-controller-attributes=can-controller-configuration={prop-seg=0, sync-jump-width=0, time-seg-1=10, time-seg-2=0}
    can communication controller J1939_Network_CANNODE_0: can-controller-attributes=can-controller-configuration={prop-seg=0, sync-jump-width=0, time-seg-1=10, time-seg-2=0}
    can communication connector Conn_Can_Network_CANNODE_0_BMS: comm-controller=Can_Network_CANNODE_0
    can communication connector Conn_J1939_Network_CANNODE_0_BMS: comm-controller=J1939_Network_CANNODE_0
package /DBC_SysDesc_Can_Network/Pkg_Units
  14 x unit:
    degC
    V
    mV
    kw
    kmPerh
    perc
    kW
    A
    Kwh
    min
    Wh
    km
    Ah
    KOhm
package /DBC_SysDesc_J1939_Network/Pkg_Cluster
  j 1939 cluster J1939_Network: protocol-name=J1939
    can physical channel J1939_Network_Channel: comm-connectors=Conn_J1939_Network_CANNODE_0_BMS
      frame Frm_CTS_CHG: id 0x1807F456, to BMS, frame-length=7, can-addressing-mode=EXTENDED
        pdu CTS_CHG: length=7
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_YearThousand}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_YearTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_YearHundred}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Year}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_SecondTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Second}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_MonthTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Month}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_MinuteTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Minute}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_HourTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Hour}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_DayTen}
            {data-filter={data-filter-type=ALWAYS, max=9, min=0, offset=0}, i-signal-in-i-pdu=CTS_SPN2823_SYNC_Day}
          signal CTS_SPN2823_SYNC_YearThousand: start 52, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_YearTen: start 44, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_YearHundred: start 48, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Year: start 40, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_SecondTen: start 4, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Second: start 0, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_MonthTen: start 36, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Month: start 32, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_MinuteTen: start 12, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Minute: start 8, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_HourTen: start 20, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Hour: start 16, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_DayTen: start 28, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
          signal CTS_SPN2823_SYNC_Day: start 24, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS
      frame Frm_RTS_CTS: id 0x1CECF456, to BMS, frame-length=8, can-addressing-mode=EXTENDED
        carries pdu ?: packing-byte-order=little-endian, start-position=0
      frame Frm_CSD_CHG: id 0x181DF456, to BMS, frame-length=8, can-addressing-mode=EXTENDED
        pdu CSD_CHG: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4294967294, min=0, offset=1}, i-signal-in-i-pdu=CSD_SPN3613_CHG_Index}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=CSD_SPN3612_E_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=600, min=0, offset=0}, i-signal-in-i-pdu=CSD_SPN3611_Time_Charged}
          signal CSD_SPN3613_CHG_Index: start 32, 32 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1, to BMS  # 充电机编号"
          signal CSD_SPN3612_E_Out: start 16, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 输出能量"
          signal CSD_SPN3611_Time_Charged: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 累计充电时间"
      frame Frm_CST_CHG: id 0x101AF456, to BMS, frame-length=4, can-addressing-mode=EXTENDED
        pdu CST_CHG: length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3521_Stop_Reason_BMSStop}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3523_Stop_Fault_U}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3523_Stop_Fault_Mismatch}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_T_Inter}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_T_CHG}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_Other}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_EmerStop}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_Deliver}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3522_Stop_Fault_CHGCnnt}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3521_Stop_Reason_Manual}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3521_Stop_Reason_Fault}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CST_SPN3521_Stop_Reason_Auto}
          signal CST_SPN3521_Stop_Reason_BMSStop: start 6, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电原因 BMS主动中止"
          signal CST_SPN3523_Stop_Fault_U: start 26, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电错误原因 电压异常"
          signal CST_SPN3523_Stop_Fault_Mismatch: start 24, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电错误原因 电流不匹配"
          signal CST_SPN3522_Stop_Fault_T_Inter: start 12, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 充电机内部过温"
          signal CST_SPN3522_Stop_Fault_T_CHG: start 8, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 充电机过温"
          signal CST_SPN3522_Stop_Fault_Other: start 18, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 其他故障"
          signal CST_SPN3522_Stop_Fault_EmerStop: start 16, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 充电机急停"
          signal CST_SPN3522_Stop_Fault_Deliver: start 14, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 电量不能传送"
          signal CST_SPN3522_Stop_Fault_CHGCnnt: start 10, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电故障原因 充电连接器故障"
          signal CST_SPN3521_Stop_Reason_Manual: start 2, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电原因 人工中止"
          signal CST_SPN3521_Stop_Reason_Fault: start 4, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电原因 故障中止"
          signal CST_SPN3521_Stop_Reason_Auto: start 0, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机中止充电原因 达到充电机设定条件中止"
      frame Frm_CHM_CHG: id 0x1826F456, to BMS, frame-length=3, can-addressing-mode=EXTENDED
        pdu CHM_CHG: length=3, transmission-mode-condition{data-filter={data-filter-type=NEW-IS-WITHIN, max=16777215, min=0, offset=0}, i-signal-in-i-pdu=CHM_SPN2600_Comm_Ver}
          signal CHM_SPN2600_Comm_Ver: start 0, 24 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1, to BMS  # 充电通讯协议版本"
      frame Frm_CRO_CHG: id 0x100AF456, to BMS, frame-length=1, can-addressing-mode=EXTENDED
        pdu CRO_CHG: length=1, transmission-mode-condition{data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=CRO_SPN2830_CHG_Ready}
          signal CRO_SPN2830_CHG_Ready: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电机输出准备就绪报文"
      frame Frm_CEM_CHG: id 0x81FF456, to BMS, frame-length=4, can-addressing-mode=EXTENDED
        pdu CEM_CHG: length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=63, min=0, offset=0}, i-signal-in-i-pdu=CEM_other}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3927_Timeout_BSD}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3926_Timeout_BST}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3925_Timeout_BCL}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3924_Timeout_BCS}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3923_Timeout_BRO}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3922_Timeout_BCP}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CEM_SPN3921_Timeout_BRM}
          signal CEM_other: start 26, 6 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 其他"
          signal CEM_SPN3927_Timeout_BSD: start 24, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收BCU充电统计报文超时"
          signal CEM_SPN3926_Timeout_BST: start 20, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收BCU中止充电报文超时"
          signal CEM_SPN3925_Timeout_BCL: start 18, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收电池充电要求报文超时"
          signal CEM_SPN3924_Timeout_BCS: start 16, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收电池充电总状态报文超时"
          signal CEM_SPN3923_Timeout_BRO: start 10, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收BCU完成充电准备报文超时"
          signal CEM_SPN3922_Timeout_BCP: start 8, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收电池充电参数报文超时"
          signal CEM_SPN3921_Timeout_BRM: start 0, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 接收BCU和车辆的辨识报文超时"
      frame Frm_CML_CHG: id 0x1808F456, to BMS, frame-length=8, can-addressing-mode=EXTENDED
        pdu CML_CHG: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=CML_SPN2827_I_Min_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=CML_SPN2826_I_Max_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=CML_SPN2825_U_Min_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=CML_SPN2824_U_Max_Out}
          signal CML_SPN2827_I_Min_Out: start 48, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1, to BMS  # 充电机最小输出电流"
          signal CML_SPN2826_I_Max_Out: start 32, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1, to BMS  # 充电机最大输出电流"
          signal CML_SPN2825_U_Min_Out: start 16, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 充电机最低输出电压"
          signal CML_SPN2824_U_Max_Out: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 充电机最高输出电压"
      frame Frm_CCS_CHG: id 0x1812F456, to BMS, frame-length=8, can-addressing-mode=EXTENDED
        pdu CCS_CHG: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=CCS_SPN3081_U_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0}, i-signal-in-i-pdu=CCS_SPN3082_I_Out}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=600, min=0, offset=0}, i-signal-in-i-pdu=CCS_SPN3083_Time_Charged}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=CCS_SPN3929_Chg_enable}
          signal CCS_SPN3081_U_Out: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 电压输出值"
          signal CCS_SPN3082_I_Out: start 16, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1, to BMS  # 电流输出值"
          signal CCS_SPN3083_Time_Charged: start 32, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1, to BMS  # 累计充电时间"
          signal CCS_SPN3929_Chg_enable: start 48, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 充电允许"
      frame Frm_CRM_CHG: id 0x1801F456, to BMS, frame-length=8, can-addressing-mode=EXTENDED
        pdu CRM_CHG: length=8
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=16777215, min=0, offset=0}, i-signal-in-i-pdu=CRM_SPN2562_CHG_Loc}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4294967295, min=0, offset=0}, i-signal-in-i-pdu=CRM_SPN2561_CHG_Index}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=CRM_SPN2560_Ack}
          signal CRM_SPN2562_CHG_Loc: start 40, 24 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1, to BMS  # 充电机/充电站所在区域编码"
          signal CRM_SPN2561_CHG_Index: start 8, 32 bit, little-endian, init-value=1, base-type=uint32, update-indication-bit-position=-1, to BMS  # 充电机编号"
          signal CRM_SPN2560_Ack: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1, to BMS  # 辨识结果"
      frame Frm_RTS: id 0x1CEC56F4, from BMS, frame-length=8, can-addressing-mode=EXTENDED
        carries pdu ?: packing-byte-order=little-endian, start-position=0
      frame Frm_BCS_BCU: id 0x1C1156F4, from BMS, frame-length=9, can-addressing-mode=EXTENDED
        pdu BCS_BCU: length=9, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BCS_SPN3075_U_Mea}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=8000, min=0}, i-signal-in-i-pdu=BCS_SPN3076_I_Mea}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2400, min=0, offset=0}, i-signal-in-i-pdu=BCS_SPN3077_Ucell_Max}
            {data-filter={data-filter-type=ALWAYS, max=15, min=0, offset=0}, i-signal-in-i-pdu=BCS_SPN3077_Ucell_Max_Grp}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=BCS_SPN3078_SOC}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=600, min=0, offset=0}, i-signal-in-i-pdu=BCS_SPN3079_Time_Remain}
          signal BCS_SPN3075_U_Mea: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 充电电压测量值"
          signal BCS_SPN3076_I_Mea: start 16, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1  # 充电电流测量值"
          signal BCS_SPN3077_Ucell_Max: start 32, 12 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 最高单体动力蓄电池电压"
          signal BCS_SPN3077_Ucell_Max_Grp: start 44, 4 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 最高单体动力蓄电池电压所在组号"
          signal BCS_SPN3078_SOC: start 48, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 当前荷电状态"
          signal BCS_SPN3079_Time_Remain: start 56, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 估算剩余充电时间"
      frame Frm_BRM_BCU: id 0x1C0256F4, from BMS, frame-length=49, can-addressing-mode=EXTENDED
        pdu BRM_BCU: length=49, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=65535, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2576_BMSVer_Year}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2576_BMSVer_Version}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=16777215, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2576_BMSVer_Reserver}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2576_BMSVer_Month}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2576_BMSVer_Day}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2575_VIN{1..17}}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2574_BMSSW_Reserved}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=16777215, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2572_PackChgCnt}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2573_PackRight}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2571_PackDay}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2571_PackMonth}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0, offset=1985}, i-signal-in-i-pdu=BRM_SPN2571_PackYear}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4294967295, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2570_PackSN}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4294967295, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2569_BatFactory}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=16777215, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2565_Ver}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2566_Bat_Type}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2567_Cap_Nom}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BRM_SPN2568_U_Nom}
          signal BRM_SPN2576_BMSVer_Year: start 352, 16 bit, little-endian, init-value=65535, base-type=uint16, update-indication-bit-position=-1
          signal BRM_SPN2576_BMSVer_Version: start 328, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2576_BMSVer_Reserver: start 368, 24 bit, little-endian, init-value=16777215, base-type=uint32, update-indication-bit-position=-1
          signal BRM_SPN2576_BMSVer_Month: start 344, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2576_BMSVer_Day: start 336, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN1: start 192, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN2: start 200, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN3: start 208, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN4: start 216, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN5: start 224, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN6: start 232, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN7: start 240, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN8: start 248, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN9: start 256, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN10: start 264, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN11: start 272, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN12: start 280, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN13: start 288, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN14: start 296, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN15: start 304, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN16: start 312, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2575_VIN17: start 320, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2574_BMSSW_Reserved: start 184, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2572_PackChgCnt: start 152, 24 bit, little-endian, init-value=16777215, base-type=uint32, update-indication-bit-position=-1
          signal BRM_SPN2573_PackRight: start 176, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2571_PackDay: start 144, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2571_PackMonth: start 136, 8 bit, little-endian, init-value=255, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2571_PackYear: start 128, 8 bit, little-endian, init-value=250, base-type=uint8, update-indication-bit-position=-1
          signal BRM_SPN2570_PackSN: start 96, 32 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1
          signal BRM_SPN2569_BatFactory: start 64, 32 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1
          signal BRM_SPN2565_Ver: start 0, 24 bit, little-endian, init-value=0, base-type=uint32, update-indication-bit-position=-1  # BCU通信协议版本号"
          signal BRM_SPN2566_Bat_Type: start 24, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 电池类型"
          signal BRM_SPN2567_Cap_Nom: start 32, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 整车动力蓄电池系统额定容量"
          signal BRM_SPN2568_U_Nom: start 48, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 整车动力蓄电池系统额定总电压"
      frame Frm_BHM_BCU: id 0x182756F4, from BMS, frame-length=2, can-addressing-mode=EXTENDED
        pdu BHM_BCU: length=2, meta-data-length=4, transmission-mode-condition{data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BHM_SPN2601_Ubat_Max_Permit}
          signal BHM_SPN2601_Ubat_Max_Permit: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 最高允许充电总电压"
      frame Frm_BSM_BCU: id 0x181356F4, from BMS, frame-length=7, can-addressing-mode=EXTENDED
        pdu BSM_BCU: length=7, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3096_Chg_Enable}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3095_OutConnector_State}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3094_Iso_State}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3093_T_Warn}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3092_I_Warn}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3091_SOC_Warn}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BSM_SPN3090_Ucell_Warn}
            {data-filter={data-filter-type=ALWAYS, max=127, min=0, offset=1}, i-signal-in-i-pdu=BSM_SPN3089_T_Min_Index}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=BSM_SPN3088_T_Min}
            {data-filter={data-filter-type=ALWAYS, max=127, min=0, offset=1}, i-signal-in-i-pdu=BSM_SPN3087_T_Max_Index}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=BSM_SPN3086_T_Max}
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=1}, i-signal-in-i-pdu=BSM_SPN3085_Ucell_Max_Index}
          signal BSM_SPN3096_Chg_Enable: start 52, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电允许"
          signal BSM_SPN3095_OutConnector_State: start 50, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池组输出连接器连接状态"
          signal BSM_SPN3094_Iso_State: start 48, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池绝缘状态"
          signal BSM_SPN3093_T_Warn: start 46, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池温度过高"
          signal BSM_SPN3092_I_Warn: start 44, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池充电过电流"
          signal BSM_SPN3091_SOC_Warn: start 42, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 整车动力蓄电池荷电状态SOC"
          signal BSM_SPN3090_Ucell_Warn: start 40, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 单体动力蓄电池电压"
          signal BSM_SPN3089_T_Min_Index: start 32, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 最低动力蓄电池温度检测点编号"
          signal BSM_SPN3088_T_Min: start 24, 8 bit, little-endian, init-value=50, base-type=uint8, update-indication-bit-position=-1  # 最低动力蓄电池温度"
          signal BSM_SPN3087_T_Max_Index: start 16, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 最高温度检测点编号"
          signal BSM_SPN3086_T_Max: start 8, 8 bit, little-endian, init-value=50, base-type=uint8, update-indication-bit-position=-1  # 最高动力蓄电池温度"
          signal BSM_SPN3085_Ucell_Max_Index: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 最高单体动力蓄电池电压所在编号"
      frame Frm_BST_BCU: id 0x101956F4, from BMS, frame-length=4, can-addressing-mode=EXTENDED
        pdu BST_BCU: length=4, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_HVRelay}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_CC2}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3511_Stop_Reason_CHGStop}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3513_Stop_Fault_U}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3513_Stop_Fault_I}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_T}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_Other}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_Iso}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_OutCnnt}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_BCUcompo}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3512_Stop_Fault_ChgCnnt}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3511_Stop_Reason_Ucell}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3511_Stop_Reason_U}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BST_SPN3511_Stop_Reason_SOC}
          signal BST_SPN3512_Stop_Fault_HVRelay: start 18, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 高压继电器故障"
          signal BST_SPN3512_Stop_Fault_CC2: start 20, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 检测点2电压检测故障"
          signal BST_SPN3511_Stop_Reason_CHGStop: start 6, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电原因 充电机主动中止"
          signal BST_SPN3513_Stop_Fault_U: start 26, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电错误原因 电压异常"
          signal BST_SPN3513_Stop_Fault_I: start 24, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电错误原因 电流过大"
          signal BST_SPN3512_Stop_Fault_T: start 16, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 电池组温度过高"
          signal BST_SPN3512_Stop_Fault_Other: start 22, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 其他故障"
          signal BST_SPN3512_Stop_Fault_Iso: start 8, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 绝缘故障"
          signal BST_SPN3512_Stop_Fault_OutCnnt: start 10, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 输出连接器过温故障"
          signal BST_SPN3512_Stop_Fault_BCUcompo: start 12, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 BCU元件过温"
          signal BST_SPN3512_Stop_Fault_ChgCnnt: start 14, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电故障原因 充电连接器故障"
          signal BST_SPN3511_Stop_Reason_Ucell: start 4, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电原因 达到单体电压的设定值"
          signal BST_SPN3511_Stop_Reason_U: start 2, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电原因 达到总电压的设定值"
          signal BST_SPN3511_Stop_Reason_SOC: start 0, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU中止充电原因 达到所需SOC目标值"
      frame Frm_BCP_BCU: id 0x1C0656F4, from BMS, frame-length=13, can-addressing-mode=EXTENDED
        pdu BCP_BCU: length=13, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2400, min=0, offset=0}, i-signal-in-i-pdu=BCP_SPN2816_Ucell_Max_Permit}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=BCP_SPN2817_I_Max_Permit}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BCP_SPN2818_kWh_Nom}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BCP_SPN2819_U_Max_Permit}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=BCP_SPN2820_T_Max_Permit}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=1000, min=0, offset=0}, i-signal-in-i-pdu=BCP_SPN2821_SOC}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BCP_SPN2822_U}
          signal BCP_SPN2816_Ucell_Max_Permit: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 单体动力蓄电池最高允许充电电压"
          signal BCP_SPN2817_I_Max_Permit: start 16, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1  # 最高允许充电电流"
          signal BCP_SPN2818_kWh_Nom: start 32, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 动力蓄电池标称总能量"
          signal BCP_SPN2819_U_Max_Permit: start 48, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 最高允许充电总电压"
          signal BCP_SPN2820_T_Max_Permit: start 64, 8 bit, little-endian, init-value=50, base-type=uint8, update-indication-bit-position=-1  # 最高允许动力蓄电池温度"
          signal BCP_SPN2821_SOC: start 72, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 整车动力蓄电池荷电状态"
          signal BCP_SPN2822_U: start 88, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 整车动力蓄电池总电压"
      frame Frm_BRO_BCU: id 0x100956F4, from BMS, frame-length=1, can-addressing-mode=EXTENDED
        pdu BRO_BCU: length=1, meta-data-length=4, transmission-mode-condition{data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BRO_SPN2829_BCU_Ready}
          signal BRO_SPN2829_BCU_Ready: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # BCU充电准备就绪报文"
      frame Frm_RTS_DT: id 0x1CEB56F4, from BMS, frame-length=8, can-addressing-mode=EXTENDED
        carries pdu ?: packing-byte-order=little-endian, start-position=0
      frame Frm_BEM_BCU: id 0x81E56F4, from BMS, frame-length=4, can-addressing-mode=EXTENDED
        pdu BEM_BCU: length=4, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=63, min=0, offset=0}, i-signal-in-i-pdu=BEM_other}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3907_Timeout_CSD}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3906_Timeout_CST}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3905_Timeout_CCS}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3904_Timeout_CRO}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3903_Timeout_CTS_CML}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3902_Timeout_SPN2560_0xAA}
            {data-filter={data-filter-type=ALWAYS, max=3, min=0, offset=0}, i-signal-in-i-pdu=BEM_SPN3901_Timeout_SPN2560_0x00}
          signal BEM_other: start 26, 6 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 其他"
          signal BEM_SPN3907_Timeout_CSD: start 24, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收充电机充电统计报文超时"
          signal BEM_SPN3906_Timeout_CST: start 18, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收充电机中止充电报文超时"
          signal BEM_SPN3905_Timeout_CCS: start 16, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收充电机充电状态报文超时"
          signal BEM_SPN3904_Timeout_CRO: start 10, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收充电机完成充电准备报文超时"
          signal BEM_SPN3903_Timeout_CTS_CML: start 8, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收充电机的时间同步和充电机最大输出能力报文超时"
          signal BEM_SPN3902_Timeout_SPN2560_0xAA: start 2, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收SPN2560=0xAA的充电机辨识报文超时"
          signal BEM_SPN3901_Timeout_SPN2560_0x00: start 0, 2 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 接收SPN2560=0x00的充电机辨识报文超时"
      frame Frm_BCL_BCU: id 0x181056F4, from BMS, frame-length=5, can-addressing-mode=EXTENDED
        pdu BCL_BCU: length=5, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=255, min=0, offset=0}, i-signal-in-i-pdu=BCL_SPN3074_ChgMode}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=4000, min=0}, i-signal-in-i-pdu=BCL_SPN3073_I_Req}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=10000, min=0, offset=0}, i-signal-in-i-pdu=BCL_SPN3072_U_Req}
          signal BCL_SPN3074_ChgMode: start 32, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 充电模式"
          signal BCL_SPN3073_I_Req: start 16, 16 bit, little-endian, init-value=4000, base-type=uint16, update-indication-bit-position=-1  # 电流需求"
          signal BCL_SPN3072_U_Req: start 0, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 电压需求"
      frame Frm_BSD_BCU: id 0x181C56F4, from BMS, frame-length=7, can-addressing-mode=EXTENDED
        pdu BSD_BCU: length=7, meta-data-length=4
          transmission-mode-conditions:
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=BSD_SPN3605_T_Max}
            {data-filter={data-filter-type=ALWAYS, max=250, min=0}, i-signal-in-i-pdu=BSD_SPN3604_T_Min}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2400, min=0, offset=0}, i-signal-in-i-pdu=BSD_SPN3603_Ucell_Max}
            {data-filter={data-filter-type=NEW-IS-WITHIN, max=2400, min=0, offset=0}, i-signal-in-i-pdu=BSD_SPN3602_Ucell_Min}
            {data-filter={data-filter-type=ALWAYS, max=100, min=0, offset=0}, i-signal-in-i-pdu=BSD_SPN3601_SOC_Final}
          signal BSD_SPN3605_T_Max: start 48, 8 bit, little-endian, init-value=50, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池最高温度"
          signal BSD_SPN3604_T_Min: start 40, 8 bit, little-endian, init-value=50, base-type=uint8, update-indication-bit-position=-1  # 动力蓄电池最低温度"
          signal BSD_SPN3603_Ucell_Max: start 24, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 动力蓄电池单体最高电压"
          signal BSD_SPN3602_Ucell_Min: start 8, 16 bit, little-endian, init-value=0, base-type=uint16, update-indication-bit-position=-1  # 动力蓄电池单体最低电压"
          signal BSD_SPN3601_SOC_Final: start 0, 8 bit, little-endian, init-value=0, base-type=uint8, update-indication-bit-position=-1  # 中止荷电状态SOC"
      frame Frm_NPDU_RX_CM_CMDT: id 0xEC0000, to BMS, frame-length=8, can-addressing-mode=EXTENDED, rx-mask=16776960
        n pdu NPDU_RX_CM_CMDT: length=8, meta-data-length=4
      frame Frm_NPDU_TX_DT: id 0xEB0000, from BMS, frame-length=8, can-addressing-mode=EXTENDED, tx-mask=16711680
        n pdu NPDU_TX_DT: length=8, meta-data-length=4
      frame Frm_NPDU_TX_CM: id 0xEC0000, from BMS, frame-length=8, can-addressing-mode=EXTENDED, tx-mask=16711680
        n pdu NPDU_TX_CM: length=8, meta-data-length=4
  j 1939 tp config J1939TpConfig_J1939_Network: communication-cluster=J1939_Network
    tp address TpAddress_0: tp-address=0
    j-1939-tp-connection broadcast=true, data-pdu=NPDU_TX_DT, flow-control-pdu=[NPDU_TX_CM, NPDU_RX_CM_CMDT], tp-pgs=[{pgn=4352, sdu=BCS_BCU}, {pgn=512, sdu=BRM_BCU}, {pgn=1536, sdu=BCP_BCU}]:
      ident J1939TpConnection_TX
    j 1939 tp node J1939TpNode_0: connector=Conn_J1939_Network_CANNODE_0_BMS, tp-address=TpAddress_0
package /DBC_SysDesc_J1939_Network/Pkg_Units
  7 x unit:
    min
    A
    V
    C
    Ah
    perc
    kWh
